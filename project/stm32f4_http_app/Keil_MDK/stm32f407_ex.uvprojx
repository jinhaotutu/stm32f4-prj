# Keil uVision project stm32f407_ex.uvprojx, settings and files
target stm32f4_project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407_ex +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_OS,OS_DEBUG=1,OS_HOOK
  c include: ..\..\..\driver;..\..\..\fwlib\inc;..\..\..\misis;..\user_code;..\..\..\sys;..\..\..\user;..\..\..\thirdlib\cJSON;..\..\..\thirdlib\EasyLogger\easylogger\inc;..\..\..\thirdlib\FreeRTOSv10.3.1\FreeRTOS\Source\include;..\..\..\thirdlib\FreeRTOSv10.3.1\FreeRTOS\Source\stm32_port;..\..\..\thirdlib\FreeRTOSv10.3.1\FreeRTOS\Source\stm32_port\RVDS\ARM_CM4F;..\..\..\thirdlib\lwip-2.1.2\port\arch;..\..\..\thirdlib\lwip-2.1.2\port\driver\stm32_eth;..\..\..\thirdlib\lwip-2.1.2\port\os;..\..\..\thirdlib\lwip-2.1.2\port;..\..\..\thirdlib\lwip-2.1.2\src\include;..\..\..\thirdlib\mongoose-6.18;..\..\..\thirdlib\mongoose-6.18\api\http_post;..\..\..\thirdlib\mongoose-6.18\api\http_webserver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group driver
    ../../../driver/: led.c
  group fwlib
    ../../../fwlib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group misis
    ../../../misis/: system_stm32f4xx.c
  group startup
    ../../../startup/: startup_stm32f40_41xxx.s
  group sys
    ../../../sys/: stm32f4xx_it.c sys_cfg.c sys_delay.c
  group cjson
    ../../../thirdlib/cJSON/: cJSON.c
  group logger
    ../../../thirdlib/EasyLogger/: easylogger_init.c
    ../../../thirdlib/EasyLogger/easylogger/port/: elog_port.c
    ../../../thirdlib/EasyLogger/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group user
    ../../../user/: main.c
  group app
    ../user_code/: user_main.c webserver.c http_client.c
  group freertos
    ../../../thirdlib/FreeRTOSv10.3.1/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../thirdlib/FreeRTOSv10.3.1/FreeRTOS/Source/stm32_port/RVDS/ARM_CM4F/: port.c
    ../../../thirdlib/FreeRTOSv10.3.1/FreeRTOS/Source/stm32_port/MemMang/: heap_4.c
    ../../../thirdlib/FreeRTOSv10.3.1/FreeRTOS/Source/stm32_port/: stm_config.c
  group lwip
    ../../../thirdlib/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../thirdlib/lwip-2.1.2/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../thirdlib/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../thirdlib/lwip-2.1.2/port/os/: sys_arch.c
    ../../../thirdlib/lwip-2.1.2/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
    ../../../thirdlib/lwip-2.1.2/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../../../thirdlib/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../thirdlib/lwip-2.1.2/port/driver/stm32_eth/: ethernetif.c eth_init.c lwip_init.c stm32f4x7_eth.c
  group http
    ../../../thirdlib/mongoose-6.18/: mongoose.c
    ../../../thirdlib/mongoose-6.18/api/http_post/: http_api.c
    ../../../thirdlib/mongoose-6.18/api/http_webserver/: http_webserver.c
